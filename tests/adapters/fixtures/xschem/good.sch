v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {step16 good deck} 0 0 0 0 0.5 0.5 {}
C {devices/vsource.sym} 100 0 0 0 {name=V1 value=1.65}
C {devices/gnd.sym} 100 100 0 0 {lab=GND}
